Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView_V2.0]
File name: Project Number
Time: 2023-10-03T13:31:58
Written by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013
Made in: 20190327_2315(x64) - Exporter 20.0.0.377 - Alternate UI 20.0.0.377
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Tue Oct 03 13:31:58 2023 * Host: arc-siwakorn * Database: C:\Users\SIWAKO~1.STI\AppData\Local\Temp\c67d8334-79e4-4b6b-a1e0-9d6d090131f3\5b9d416b-43b2-4c3c-9c77-e7b9db599328\ifc * Database version: 5507 * Database creation date: Tue Oct 03 13:31:55 2023 * Schema: IFC2X3 * Model: DataRepository.ifc * Model creation date: Tue Oct 03 13:31:55 2023 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Tue Oct 03 13:31:55 2023 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcProject, Project Number
LongName: Project Name; Phase: Project Status

# IfcSite, Default
RefLatitude: 42, 21, 31, 181945; RefLongitude: -71, -3, -24, -263305; RefElevation: 0 mm

# IfcBuilding
Pset_ProductRequirements - Category: Project Information
Pset_BuildingCommon - NumberOfStoreys: 1

# IfcBuildingStorey: Level:8mm Head, Level 1
LongName: Level 1; Elevation: 0 mm
Pset_AirSideSystemInformation - Name: Level 1
Pset_ProductRequirements - Name: Level 1; Category: Levels

# IfcFlowTerminal: CCASP406-0005060C0_REVIT:Chrome Concept Pillow button, CCASP406-0005060C0_REVIT:Chrome Concept Pillow button:206360
In: Level 1
Material: -
Pset_DistributionFlowElementCommon - Reference: Chrome Concept Pillow button; sets with these values: 2
Pset_ManufacturerTypeInformation - Manufacturer: American Standard
Pset_ProductRequirements - Category: Plumbing Fixtures
